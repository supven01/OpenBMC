FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://ethanolx.cfg"
#SRC_URI_append_<MACHINE> = " file://aspeed-bmc-amd-ethanolx.dts"
